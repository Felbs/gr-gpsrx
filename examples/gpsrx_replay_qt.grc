options:
  parameters:
    id: gpsrx_replay_qt
    title: 'GPS receiver: capture file, with the sky panel'
    author: gr-gpsrx
    generate_options: qt_gui
    output_language: python
    description: File -> Receiver -> Sky Panel.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
    comment: '2.048 MS/s: 2 samples per chip, the tested rate'
  states: {}
- name: capture
  id: parameter
  parameters:
    label: Capture file (.cs16, interleaved int16 I/Q)
    type: str
    value: '"capture.cs16"'
    short_id: c
  states: {}
- name: fix_file
  id: parameter
  parameters:
    label: Fix file (keep it out of any repository)
    type: str
    value: '""'
    short_id: o
  states: {}
- name: src
  id: blocks_file_source
  parameters:
    file: capture
    type: short
    repeat: 'False'
    comment: int16 I,Q pairs
  states: {}
- name: to_c
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
    scale_factor: '32768.0'
  states: {}
- name: rx
  id: gpsrx_receiver
  parameters:
    samp_rate: samp_rate
    n_channels: '8'
    interval_s: '100.0'
    threshold: '2.5'
    iono_file: '""'
    fix_file: fix_file
    hold: 'True'
    engine: '''auto'''
    eph_file: '""'
    smoothing: '100'
    kf_vel_sd: '4.0'
    lo_search_hz: '0.0'
    n_galileo: '0'
  states: {}
- name: panel
  id: gpsrx_sky_panel
  parameters:
    label: '"GPS receiver (replay)"'
    private: private
    gui_hint: 0,0,1,1
  states: {}
- name: private
  id: parameter
  parameters:
    label: Private view (screenshots)
    type: intx
    value: '0'
    short_id: p
  states: {}

connections:
- [src, '0', to_c, '0']
- [to_c, '0', rx, '0']
- [rx, sky, panel, sky]
- [rx, status, panel, status]
- [rx, obs, panel, obs]
- [rx, nav, panel, nav]
- [rx, fix, panel, fix]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
