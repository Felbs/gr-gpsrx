options:
  parameters:
    id: gpsrx_canvas
    title: GPS receiver, block by block
    author: gr-gpsrx
    generate_options: no_gui
    output_language: python
    run_options: run
    description: Acquisition -> Channels -> Nav Decoders -> PVT -> Status, every wire visible.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
    comment: '2.048 MS/s: 2 samples per chip, the tested rate'
  states: {}
- name: capture
  id: parameter
  parameters:
    label: Capture file (.cs16, interleaved int16 I/Q)
    type: str
    value: '"capture.cs16"'
    short_id: c
  states: {}
- name: fix_file
  id: parameter
  parameters:
    label: Fix file (keep it out of any repository)
    type: str
    value: '""'
    short_id: o
  states: {}
- name: src
  id: blocks_file_source
  parameters:
    file: capture
    type: short
    repeat: 'False'
    comment: int16 I,Q pairs
  states: {}
- name: to_c
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
    scale_factor: '32768.0'
  states: {}
- name: acq
  id: gpsrx_acquisition
  parameters:
    samp_rate: samp_rate
    n_slots: '6'
    interval_s: '100.0'
    threshold: '2.5'
    n_noncoh: '100'
    snapshot_ms: '110'
    settle_s: '0.5'
    hold: 'True'
    lo_search_hz: '0.0'
    system: '''GPS'''
    slot0: '0'
    comment: finds the satellites; assigns each to a Channel slot
  states: {}
- name: pvt
  id: gpsrx_pvt
  parameters:
    samp_rate: samp_rate
    average: '15'
    iono_file: '""'
    fix_file: fix_file
    eph_file: '""'
    smoothing: '100'
    kf_vel_sd: '4.0'
    comment: period counts + anchors -> pseudoranges -> weighted LS + RAIM, Hatch, Kalman
  states: {}
- name: status
  id: gpsrx_status
  parameters:
    every_s: '2.0'
    log_file: '""'
  states: {}
- name: ch0
  id: gpsrx_channel
  parameters:
    samp_rate: samp_rate
    slot: '0'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 0: NCO, E/P/L, PLL, DLL; counts code epochs (Python)'
  states: {}
- name: nav0
  id: gpsrx_nav_decoder
  parameters:
    slot: '0'
    comment: bits -> words -> subframes -> anchor
  states: {}
- name: ch1
  id: gpsrx_channel_cc
  parameters:
    samp_rate: samp_rate
    slot: '1'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 1: NCO, E/P/L, PLL, DLL; counts code epochs (C++)'
  states: {}
- name: nav1
  id: gpsrx_nav_decoder
  parameters:
    slot: '1'
    comment: bits -> words -> subframes -> anchor
  states: {}
- name: ch2
  id: gpsrx_channel
  parameters:
    samp_rate: samp_rate
    slot: '2'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 2: NCO, E/P/L, PLL, DLL; counts code epochs (Python)'
  states: {}
- name: nav2
  id: gpsrx_nav_decoder
  parameters:
    slot: '2'
    comment: bits -> words -> subframes -> anchor
  states: {}
- name: ch3
  id: gpsrx_channel_cc
  parameters:
    samp_rate: samp_rate
    slot: '3'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 3: NCO, E/P/L, PLL, DLL; counts code epochs (C++)'
  states: {}
- name: nav3
  id: gpsrx_nav_decoder
  parameters:
    slot: '3'
    comment: bits -> words -> subframes -> anchor
  states: {}
- name: ch4
  id: gpsrx_channel
  parameters:
    samp_rate: samp_rate
    slot: '4'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 4: NCO, E/P/L, PLL, DLL; counts code epochs (Python)'
  states: {}
- name: nav4
  id: gpsrx_nav_decoder
  parameters:
    slot: '4'
    comment: bits -> words -> subframes -> anchor
  states: {}
- name: ch5
  id: gpsrx_channel_cc
  parameters:
    samp_rate: samp_rate
    slot: '5'
    pll_bw: '18.0'
    dll_bw: '2.0'
    obs_every_ms: '1000'
    signal: '''L1CA'''
    comment: 'slot 5: NCO, E/P/L, PLL, DLL; counts code epochs (C++)'
  states: {}
- name: nav5
  id: gpsrx_nav_decoder
  parameters:
    slot: '5'
    comment: bits -> words -> subframes -> anchor
  states: {}

connections:
- [src, '0', to_c, '0']
- [to_c, '0', acq, '0']
- [acq, sky, status, sky]
- [pvt, fix, status, fix]
- [to_c, '0', ch0, '0']
- [acq, assign, ch0, assign]
- [ch0, status, acq, status]
- [ch0, '0', nav0, '0']
- [ch0, obs, pvt, obs]
- [nav0, nav, pvt, nav]
- [ch0, status, pvt, status]
- [ch0, status, status, status]
- [ch0, obs, status, obs]
- [nav0, nav, status, nav]
- [to_c, '0', ch1, '0']
- [acq, assign, ch1, assign]
- [ch1, status, acq, status]
- [ch1, '0', nav1, '0']
- [ch1, obs, pvt, obs]
- [nav1, nav, pvt, nav]
- [ch1, status, pvt, status]
- [ch1, status, status, status]
- [ch1, obs, status, obs]
- [nav1, nav, status, nav]
- [to_c, '0', ch2, '0']
- [acq, assign, ch2, assign]
- [ch2, status, acq, status]
- [ch2, '0', nav2, '0']
- [ch2, obs, pvt, obs]
- [nav2, nav, pvt, nav]
- [ch2, status, pvt, status]
- [ch2, status, status, status]
- [ch2, obs, status, obs]
- [nav2, nav, status, nav]
- [to_c, '0', ch3, '0']
- [acq, assign, ch3, assign]
- [ch3, status, acq, status]
- [ch3, '0', nav3, '0']
- [ch3, obs, pvt, obs]
- [nav3, nav, pvt, nav]
- [ch3, status, pvt, status]
- [ch3, status, status, status]
- [ch3, obs, status, obs]
- [nav3, nav, status, nav]
- [to_c, '0', ch4, '0']
- [acq, assign, ch4, assign]
- [ch4, status, acq, status]
- [ch4, '0', nav4, '0']
- [ch4, obs, pvt, obs]
- [nav4, nav, pvt, nav]
- [ch4, status, pvt, status]
- [ch4, status, status, status]
- [ch4, obs, status, obs]
- [nav4, nav, status, nav]
- [to_c, '0', ch5, '0']
- [acq, assign, ch5, assign]
- [ch5, status, acq, status]
- [ch5, '0', nav5, '0']
- [ch5, obs, pvt, obs]
- [nav5, nav, pvt, nav]
- [ch5, status, pvt, status]
- [ch5, status, status, status]
- [ch5, obs, status, obs]
- [nav5, nav, status, nav]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
