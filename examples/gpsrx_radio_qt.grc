options:
  parameters:
    id: gpsrx_radio_qt
    title: 'GPS receiver: radio, with the sky panel'
    author: gr-gpsrx
    generate_options: qt_gui
    output_language: python
    description: SoapySDR radio -> Receiver -> Sky Panel, spectrum.
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: driver
  id: parameter
  parameters:
    label: SoapySDR driver
    type: str
    value: '"sdrplay"'
    short_id: d
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Antenna port
    type: str
    value: '""'
    short_id: a
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Overall gain (dB)
    type: eng_float
    value: '40'
    short_id: g
    comment: or tune the elements with gr-rxtune
  states: {}
- name: settings
  id: parameter
  parameters:
    label: Channel settings (key=value,...)
    type: str
    value: '""'
    short_id: s
    comment: 'bias-T for an active antenna is a DEVICE setting on SDRplay (biasT_ctrl), not a channel one: util/run_qt_shot.py ... --call src.write_setting(''biasT_ctrl'',''true'')'
  states: {}
- name: fix_file
  id: parameter
  parameters:
    label: Fix file (keep it out of any repository)
    type: str
    value: '""'
    short_id: o
  states: {}
- name: lo_search
  id: parameter
  parameters:
    label: LO offset search +-Hz (50000 for an RTL-SDR, 0 = TCXO radio)
    type: eng_float
    value: '0'
    short_id: l
  states: {}
- name: src
  id: soapy_custom_source
  parameters:
    driver: driver
    type: fc32
    dev_args: '""'
    samp_rate: samp_rate
    center_freq0: 1575.42e6
    bandwidth0: 2.5e6
    antenna0: antenna
    gain0: gain
    agc0: 'True'
    settings0: settings
    minoutbuf: '4194304'
    comment: 'L1 C/A: 1575.42 MHz. GPS is under the noise, so the AGC only sees noise - and that is fine'
  states: {}
- name: rx
  id: gpsrx_receiver
  parameters:
    samp_rate: samp_rate
    n_channels: '8'
    interval_s: '20.0'
    threshold: '2.5'
    iono_file: '""'
    fix_file: fix_file
    hold: 'False'
    engine: '''cpp'''
    eph_file: '""'
    smoothing: '100'
    kf_vel_sd: '4.0'
    lo_search_hz: lo_search
    n_galileo: '0'
    comment: live needs the C++ Channel (util/build_win.cmd, or cmake on Linux)
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"L1 baseband (the signal is below the noise)"'
    fftsize: '1024'
    fc: '0'
    bw: samp_rate
    average: '0.02'
    gui_hint: 0,0,1,1
  states: {}
- name: panel
  id: gpsrx_sky_panel
  parameters:
    label: '"GPS receiver"'
    private: private
    gui_hint: 1,0,1,1
  states: {}
- name: private
  id: parameter
  parameters:
    label: Private view (screenshots)
    type: intx
    value: '0'
    short_id: p
  states: {}
- name: bias_t
  id: parameter
  parameters:
    label: 'Bias-T (1 = active antenna; SDRplay: Antenna B only)'
    type: intx
    value: '0'
    short_id: b
  states: {}
- name: bias_t_snippet
  id: snippet
  parameters:
    code: |-
      # bias-T is a DEVICE-level SoapySDR setting; gr-soapy's per-channel "settings" reject it
      if bias_t:
          self.src.write_setting("biasT_ctrl", "true")
    section: main_after_init
  states: {}

connections:
- [src, '0', rx, '0']
- [src, '0', spectrum, '0']
- [rx, sky, panel, sky]
- [rx, status, panel, status]
- [rx, obs, panel, obs]
- [rx, nav, panel, nav]
- [rx, fix, panel, fix]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
